# Keil uVision project FC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FC
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\bsp;.\sensor;.\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ./bsp/: dma.c iwdg.c led.c pwm_in.c pwm_out.c SysTick.c usart.c usart.h
  group sensor
    ./sensor/: imu.c mpu6050.c mpuiic.c mymath.c bmpiic.c bmp180.c bmp180.h bmpiic.h bd.c bd.h
  group user
    ./user/: control.c main.c model.c niming.c task.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
